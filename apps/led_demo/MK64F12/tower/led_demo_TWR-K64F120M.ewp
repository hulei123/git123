# IAR project led_demo_TWR-K64F120M.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MK64FN1M0VMD12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_FLASH_CONFIG
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_MK64F12_Tower.bin
  ILINK.IlinkOutputFile: led_demo_TWR-K64F120M_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK64F12\K64FN1Mxxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_TWR-K64F120M_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK64F12\K64FN1Mxxx12_application_0xA000.icf
  group k64f12
    ../src/: main.c startup_MK64F12.s
    ../../../../src/startup/MK64F12/: system_MK64F12.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
