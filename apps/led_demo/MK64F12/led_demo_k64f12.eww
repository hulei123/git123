<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freedom\led_demo_FRDM-K64F.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tower\led_demo_TWR-K64F120M.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Configurations</name>
      <member>
        <project>led_demo_FRDM-K64F</project>
        <configuration>Debug_0000</configuration>
      </member>
      <member>
        <project>led_demo_FRDM-K64F</project>
        <configuration>Debug_a000</configuration>
      </member>
      <member>
        <project>led_demo_TWR-K64F120M</project>
        <configuration>Debug_0000</configuration>
      </member>
      <member>
        <project>led_demo_TWR-K64F120M</project>
        <configuration>Debug_a000</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


