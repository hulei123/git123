# IAR project led_demo_TWR-KV46F15.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx15 Freescale MKV46F256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MKV46F256VLL15; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_TWR-KV46F15.bin
  ILINK.IlinkOutputFile: led_demo_TWR-KV46F15_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV46F15\KV46F256xxx15_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DEBUG; CPU_MKV46F256VLL15
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: led_demo_TWR-MKV46F15.bin
  ILINK.IlinkOutputFile: led_demo_TWR-KV46F15_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV46F15\KV46F256xxx15_application_0xa000.icf
  group kv46f15
    ../src/: main.c system_MKV46F15.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MKV46F15.s
