# IAR project led_demo_TWR-K65F180M.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; IAR; TOWER
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_TWR-K65F180M.bin
  ILINK.IlinkOutputFile: led_demo_TWR-K65F180M_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK65F18\K65FN2Mxxx18_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: led_demo_TWR-K65F180M_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK65F18\K65FN2Mxxx18_application_0xA000.icf
  group k65f18
    ../src/: main.c system_MK65F18.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MK65F18.s
