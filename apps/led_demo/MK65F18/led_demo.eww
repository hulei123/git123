<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\tower\led_demo_TWR-K65F180M.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Configurations</name>
      <member>
        <project>led_demo_TWR-K65F180M</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>led_demo_TWR-K65F180M</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


