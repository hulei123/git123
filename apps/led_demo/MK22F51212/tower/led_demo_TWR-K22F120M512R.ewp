# IAR project led_demo_TWR-K22F120M512R.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MK22FN512VDC12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_FLASH_CONFIG
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_MK22F51212_Tower.bin
  ILINK.IlinkOutputFile: led_demo_TWR-K22F120M512R_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK22F51212\K22FN512xxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_TWR-K22F120M512R_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK22F51212\K22FN512xxx12_application_0xA000.icf
  group k22f512
    ../src/: main.c system_MK22F51212.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MK22F51212.s
