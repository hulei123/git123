# IAR project led_demo_FRDM-KL25Z.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKL25Z128VLK4; FREEDOM; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_FLASH_CONFIG; FREEDOM
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_FRDM-KL25Z_0000.bin
  ILINK.IlinkOutputFile: led_demo_FRDM-KL25Z_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKL25Z4\KL25Z128xxx4_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_8000 (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG; FREEDOM
  OBJCOPY.OOCOutputFile: led_demo_FRDM-KL25Z.bin
  ILINK.IlinkOutputFile: led_demo_FRDM-KL25Z_8000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKL25Z4\KL25Z128xxx4_application_0x8000.icf
  group kl25z4
    ../src/: main.c startup_MKL25Z4.s system_MKL25Z4.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
