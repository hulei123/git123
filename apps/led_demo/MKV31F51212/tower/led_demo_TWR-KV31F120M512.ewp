# IAR project led_demo_TWR-KV31F120M512.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MKV31F512VLL12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_TWR-KV31F120M512.bin
  ILINK.IlinkOutputFile: led_demo_TWR-KV31F120M512_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV31F51212\KV31F512xxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DEBUG; CPU_MKV31F512VLL12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: led_demo_TWR-KV31F120M512_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV31F51212\KV31F512xxx12_application_0xA000.icf
  group kv31f512
    ../src/: main.c system_MKV31F51212.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MKV31F51212.s
