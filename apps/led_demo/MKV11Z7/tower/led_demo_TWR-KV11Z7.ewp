# IAR project led_demo_TWR-KV11Z7.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 Freescale MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MKV11Z128VLH7; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_TWR-KV11Z7.bin
  ILINK.IlinkOutputFile: led_demo_TWR-KV11Z7_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV11Z7\KV11Z128xxx7_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DEBUG; CPU_MKV11Z128VLH7
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: led_demo_TWR-KV11Z7_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV11Z7\KV11Z128xxx7_application_0xa000.icf
  group kv11z7
    ../src/: main.c system_MKV11Z7.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MKV11Z7.s
