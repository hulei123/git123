# IAR project led_demo_TWR-K22F120M256R.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN256xxx12 Freescale MK22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MK22FN256VDC12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_HAS_FLASH_CONFIG
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_MK22F25612_Tower.bin
  ILINK.IlinkOutputFile: led_demo_TWR-K22F120M256R_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK22F25612\K22FN256xxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BL_HAS_BOOTLOADER_CONFIG
  ILINK.IlinkOutputFile: led_demo_TWR-K22F120M256R_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MK22F25612\K22FN256xxx12_application_0xA000.icf
  group k22f256
    ../src/: main.c system_MK22F25612.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MK22F25612.s
