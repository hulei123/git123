# IAR project led_demo_TWR-KV31F120M256.ewp, settings and files
configuration Debug_0000 (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F256xxx12 Freescale MKV31F256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TOWER; CPU_MKV31F256VLL12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: led_demo_TWR-KV31F120M256.bin
  ILINK.IlinkOutputFile: led_demo_TWR-KV31F120M256_0000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV31F25612\KV31F256xxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug_a000 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; DEBUG; CPU_MKV31F256VLL12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: led_demo_TWR-KV31F120M256_a000.elf
  ILINK.IlinkIcfFile: ..\..\..\..\targets\common\linker\iar\MKV31F25612\KV31F256xxx12_application_0xA000.icf
  group kv31f256
    ../src/: main.c system_MKV31F25612.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../src/: startup_MKV31F25612.s
