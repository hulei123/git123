# IAR project bus_pal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREEDOM; DEBUG; CPU_MKL25Z128VLK4; DISABLE_WDOG=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\src\include; ..\..\..\src\include\device; ..\..\..\src\drivers; ..\..\..\src\startup; ..\..\..\src; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_TARGET_FLASH
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: freedom_bootloader.srec
  ILINK.IlinkOutputFile: bus_pal.elf
  ILINK.IlinkIcfFile: ..\..\..\apps\bus_pal\linker\iar\bus_pal.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FREEDOM; CPU_MKL25Z128VLK4; NDEBUG; DISABLE_WDOG=1
  ICCARM.CCIncludePath2: ..\..\..\src\include; ..\..\..\src\include\device; ..\..\..\src\drivers; ..\..\..\src\startup; ..\..\..\src\utilities; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BL_TARGET_FLASH
  ILINK.IlinkOutputFile: freedom_bootloader.elf
  group src/bus_pal/src
    ../src/: bus_pal_hardware.c bus_pal_hardware.h command_handle.c command_handle.h main.c
  group src/drivers/i2c/master
    ../../../src/drivers/i2c/master/: fsl_i2c_irq.c fsl_i2c_master_driver.h
  group src/drivers/i2c/master/hal
    ../../../src/drivers/i2c/master/hal/: fsl_i2c_features.h fsl_i2c_hal.c fsl_i2c_hal.h
  group src/drivers/i2c/master/src
    ../../../src/drivers/i2c/master/src/: fsl_i2c_master_driver.c
  group src/drivers/microseconds
    ../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/spi
    ../../../src/drivers/spi/: fsl_spi_master_driver.h fsl_spi_types.h
  group src/drivers/spi/hal
    ../../../src/drivers/spi/hal/: fsl_spi_features.h fsl_spi_hal.c fsl_spi_hal.h
  group src/drivers/spi/src
    ../../../src/drivers/spi/src/: fsl_spi_master_driver.c fsl_spi_shared_irqs.c fsl_spi_shared_irqs.h
  group src/drivers/uart
    ../../../src/drivers/uart/: uart0.c uart0.h
  group src/startup
    ../../../src/startup/: boot.s crt0.s startup.c
    ../../../src/startup/MKL25Z4/: startup_MKL25Z4.s system_MKL25Z4.c
  group src/utilities
    ../../../src/utilities/src/: bootloader_tree_stub.c fsl_rtos_abstraction.c fsl_assert.c
