# IAR project bus_pal_TWR-KV46F15.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx15 Freescale MKV46F256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL15; DISABLE_WDOG=1; IAR; TOWER; BUSPAL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\targets\MKV46F15\src; ..\..\..\src\include; ..\..\..\src\include\device; ..\..\..\src\drivers; ..\..\..\src\startup; ..\..\..\src; ..\src; src; dspi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_TARGET_FLASH
  AARM.AUserIncludes: ..\..\..\src\include
  OBJCOPY.OOCOutputFile: bus_pal_TWR-KV46F15.srec
  ILINK.IlinkOutputFile: bus_pal_TWR-KV46F15.elf
  ILINK.IlinkIcfFile: ..\..\..\apps\bus_pal\linker\iar\bus_pal.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKV46F256VLL15; NDEBUG; DISABLE_WDOG=1; BUSPAL=1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BL_TARGET_FLASH
  group src/bus_pal_TWR-KV46F15/src
    src/: bus_pal_hardware.c bus_pal_hardware.h
    ../src/: buspal_config.h command_handle.c command_handle.h main.c
  group src/drivers/dspi
    dspi/: fsl_dspi_hal.h fsl_dspi_master_driver.h fsl_dspi_slave_driver.h
  group src/drivers/dspi/hal
    dspi/hal/: fsl_dspi_hal.c
  group src/drivers/dspi/src
    dspi/src/: fsl_dspi_common.c fsl_dspi_irq.c fsl_dspi_master_driver.c fsl_dspi_shared_function.c fsl_dspi_shared_function.h fsl_dspi_slave_driver.c
  group src/drivers/flexcan
    ../../../src/drivers/flexcan/: fsl_flexcan_driver.h
  group src/drivers/flexcan/hal
    ../../../src/drivers/flexcan/hal/: fsl_flexcan_hal.c fsl_flexcan_hal.h
  group src/drivers/flexcan/src
    ../../../src/drivers/flexcan/src/: fsl_flexcan_common.c fsl_flexcan_driver.c fsl_flexcan_irq.c
  group src/drivers/i2c/master
    ../../../src/drivers/i2c/master/: fsl_i2c_irq.c fsl_i2c_master_driver.h
  group src/drivers/i2c/master/hal
    ../../../src/drivers/i2c/master/hal/: fsl_i2c_hal.c fsl_i2c_hal.h
  group src/drivers/i2c/master/src
    ../../../src/drivers/i2c/master/src/: fsl_i2c_master_driver.c
  group src/drivers/microseconds
    ../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/uart
    ../../../src/drivers/uart/: scuart.c scuart.h
  group src/startup
    ../../../src/startup/: boot.s crt0.s startup.c
    ../../../src/startup/MKV46F15/iar/: startup_MKV46F15.s
    ../../../src/startup/MKV46F15/: system_MKV46F15.c
  group src/utilities
    ../../../src/utilities/src/: bootloader_tree_stub.c fsl_assert.c fsl_rtos_abstraction.c
