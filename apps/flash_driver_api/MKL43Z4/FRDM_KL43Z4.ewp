# IAR project FRDM_KL43Z4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; DEBUG; BL_CONFIG_LPUART
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\include\device; ..\..\..\src\drivers; ..\..\..\src\startup\MKL43Z4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KL43Z4.srec
  ILINK.IlinkOutputFile: FRDM_KL43Z4.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; NDEBUG; BL_CONFIG_LPUART
  ICCARM.CCOptLevel: 3
  group FRDM-KL43Z
    src/: hardware_init_MKL43Z4.c
  group link
    ../../../platform/devices/MKL03Z4/linker/iar/: MKL03Z32xxx4_flash.icf
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: flash.h flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/hal/: fsl_lpuart_hal_common_configurations.c
  group src/startup
    ../../../src/startup/: crt0.s startup.c
    ../../../src/startup/MKL43Z4/iar/: startup_MKL43Z4.s
    ../../../src/startup/MKL43Z4/: system_MKL43Z4.c
