# IAR project flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx15 Freescale MKV46F256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL15; IAR; BL_TARGET_RAM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../src; ../../../../src/include; ../../../../src/include/device; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Debug
  ILINK.IlinkOutputFile: flashloader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKV46F15/KV46F256xxx15_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Release
  group link
    ../../../common/linker/iar/MKV46F15/: KV46F256xxx15_ram_flashloader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../../../src/startup/MKV46F15/iar/: startup_MKV46F15.s
    ../../src/: system_MKV46F15.c
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h command.h context.h peripheral.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: scuart_peripheral_interface.c dspi_peripheral_interface.c i2c_peripheral_interface.c flexcan_peripheral_interface.c app_crc_check.c bl_user_entry.c bootloader.c bootloader_context.c bootloader_exception_handler.c bootloader_tree_root.c command.c shutdown_cleanup.c
  group src/drivers/crc/src
    ../../../../src/drivers/crc/src/: fsl_crc_common.c fsl_crc_driver.c
  group src/drivers/crc/hal
    ../../../../src/drivers/crc/hal/: fsl_crc_hal.c
  group src/drivers/flash
    ../../../../src/drivers/flash/src/: flash_densities_k_series.c fsl_flash_features.h flash_densities.h flash_cache_clear.c flash_command_sequence.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h flash_is_execute_only.c flash_program_once.c flash_read_once.c flash_read_resource.c
    ../../../../src/drivers/flash/: flash.h
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: scuart.h scuart.c
  group src/drivers/i2c
    ../../../../src/drivers/i2c/slave/: fsl_i2c_slave_driver.h
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/slave/src/: fsl_i2c_slave_driver.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi_types.h fsl_dspi_slave_driver.h
  group src/drivers/dspi/hal
    ../../../../src/drivers/dspi/hal/: fsl_dspi_features.h fsl_dspi_hal.h fsl_dspi_hal.c
  group src/drivers/dspi/src
    ../../../../src/drivers/dspi/src/: fsl_dspi_slave_driver.c fsl_dspi_shared_irqs.c
  group src/drivers/flexcan
    ../../../../src/drivers/flexcan/: fsl_flexcan_driver.h
  group src/drivers/flexcan/hal
    ../../../../src/drivers/flexcan/hal/: fsl_flexcan_hal.h fsl_flexcan_hal.c
  group src/drivers/flexcan/src
    ../../../../src/drivers/flexcan/src/: fsl_flexcan_common.c fsl_flexcan_driver.c fsl_flexcan_irq.c
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: sram_init_cm4.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group kv46f15
    ../../src/: bootloader_config.h clock_config_kv46f15.c hardware_init_kv46f15.c memory_map_kv46f15.c peripherals_kv46f15.c peripherals_pinmux.h target_config.h
    ../../../common/src/: pinmux_utility_common.c bl_dspi_irq_config_common.c bl_i2c_irq_config_common.c
