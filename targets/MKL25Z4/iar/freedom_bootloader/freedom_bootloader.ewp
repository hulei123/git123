# IAR project freedom_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; CPU_IS_ARM_CORTEX_M0P=1; IAR; FREEDOM; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../src; ../../../../src/include; ../../../../src/include/device; ../../../../src; ../../../../src/autobaud; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/uart; ../../../../src/usb_stack/hid_device; ../../../../src/usb_stack/adapter/sources; ../../../../src/usb_stack/adapter/sources/bm; ../../../../src/usb_stack/os/bm; ../../../../src/usb_stack/platform/arch/cortex_m; ../../../../src/usb_stack/platform/soc/MKL25Z; ../../../../src/usb_stack/platform/bsp/frdmkl25z; ../../../../src/usb_stack/usb_core/device/include; ../../../../src/usb_stack/usb_core/device/include/frdmkl25z; ../../../../src/usb_stack/usb_core/device/sources; ../../../../src/usb_stack/usb_core/device/sources/bsp/frdmkl25z; ../../../../src/usb_stack/usb_core/device/sources/classes/common; ../../../../src/usb_stack/usb_core/device/sources/classes/hid; ../../../../src/usb_stack/usb_core/device/sources/classes/include; ../../../../src/usb_stack/usb_core/device/sources/controller; ../../../../src/usb_stack/usb_core/device/sources/controller/khci; ../../../../src/usb_stack/usb_core/device/sources/controller/ehci; ../../../../src/usb_stack/usb_core/hal; ../../../../src/usb_stack/usb_core/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: freedom_bootloader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKL25Z4/KL25Z128xxx4_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  group link
    ../../../common/linker/iar/MKL25Z4/: KL25Z128xxx4_application_0x0000.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../../../src/startup/MKL25Z4/: startup_MKL25Z4.s
    ../../src/: system_MKL25Z4.c
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h command.h context.h peripheral.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: uart0_peripheral_interface.c spi_peripheral_interface.c i2c_peripheral_interface.c usb_hs_hid_peripheral_interface.c bl_user_entry.c bootloader.c bootloader_context.c bootloader_exception_handler.c bootloader_tree_root.c command.c shutdown_cleanup.c
  group src/drivers/flash
    ../../../../src/drivers/flash/src/: flash_densities_kl_series.c fsl_flash_features.h flash_densities.h flash_cache_clear.c flash_command_sequence.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h flash_is_execute_only.c flash_program_once.c flash_read_once.c flash_read_resource.c
    ../../../../src/drivers/flash/: flash.h
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_pit.c
  group src/drivers/systick
    ../../../../src/drivers/systick/: systick.h
  group src/drivers/systick/src
    ../../../../src/drivers/systick/src/: systick.c
  group src/drivers/watchdog
    ../../../../src/drivers/watchdog/: fsl_watchdog.h
  group src/drivers/watchdog/src
    ../../../../src/drivers/watchdog/src/: fsl_watchdog_cop.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: uart0.h uart0.c uart.h uart.c
  group src/drivers/i2c
    ../../../../src/drivers/i2c/slave/: fsl_i2c_slave_driver.h
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/slave/src/: fsl_i2c_slave_driver.c
  group src/drivers/spi
    ../../../../src/drivers/spi/: fsl_spi_types.h fsl_spi_slave_driver.h
  group src/drivers/spi/hal
    ../../../../src/drivers/spi/hal/: fsl_spi_features.h fsl_spi_hal.h fsl_spi_hal.c
  group src/drivers/spi/src
    ../../../../src/drivers/spi/src/: fsl_spi_slave_driver.c
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/usb_stack/adapter/sources
    ../../../../src/usb_stack/adapter/sources/: adapter.h adapter_types.h
  group src/usb_stack/adapter/sources/bm
    ../../../../src/usb_stack/adapter/sources/bm/: adapter_bm.c adapter_bm.h adapter_cfg.h
  group src/usb_stack/hid_device
    ../../../../src/usb_stack/hid_device/: bootloader_hid_report_ids.h USB_Config.h usb_descriptor.c usb_descriptor.h
    ../../../../src/usb_stack/hid_device/hid_device/: user_config.h
  group src/usb_stack/os/bm
    ../../../../src/usb_stack/os/bm/: bmevent.c bmevent.h bmisr.c bmmsgq.c bmmsgq.h bmsem.c bmsem.h mem_util.c mem_util.h poll.c poll.h
  group src/usb_stack/platform/arch/cortex_m
    ../../../../src/usb_stack/platform/arch/cortex_m/: nvic.c nvic.h
  group src/usb_stack/platform/bsp/frdmkl25z
    ../../../../src/usb_stack/platform/bsp/frdmkl25z/: bsp.h derivative.h
  group src/usb_stack/platform/soc/MKL25Z
    ../../../../src/usb_stack/platform/soc/MKL25Z/: soc.h soc_config.h soc_isr.c soc_isr.h soc_pit.c soc_pit.h soc_usb.c
  group src/usb_stack/usb_core/device/include
    ../../../../src/usb_stack/usb_core/device/include/: usb_device_stack_interface.h
  group src/usb_stack/usb_core/device/include/frdmkl25z
    ../../../../src/usb_stack/usb_core/device/include/frdmkl25z/: usb_device_config.h
  group src/usb_stack/usb_core/device/sources/bsp/frdmkl25z
    ../../../../src/usb_stack/usb_core/device/sources/bsp/frdmkl25z/: usb_dev_bsp.c
  group src/usb_stack/usb_core/device/sources/classes/common
    ../../../../src/usb_stack/usb_core/device/sources/classes/common/: usb_class.c usb_class_internal.h
  group src/usb_stack/usb_core/device/sources/classes/hid
    ../../../../src/usb_stack/usb_core/device/sources/classes/hid/: usb_hid.c usb_hid.h usb_hid_config.h
  group src/usb_stack/usb_core/device/sources/classes/include
    ../../../../src/usb_stack/usb_core/device/sources/classes/include/: usb_class.h usb_class_hid.h
  group src/usb_stack/usb_core/device/sources/controller
    ../../../../src/usb_stack/usb_core/device/sources/controller/: ehci_interface.c khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group src/usb_stack/usb_core/device/sources/controller/ehci
    ../../../../src/usb_stack/usb_core/device/sources/controller/ehci/: ehci_dev_main.c ehci_dev_main.h ehci_usbprv.h
  group src/usb_stack/usb_core/device/sources/controller/khci
    ../../../../src/usb_stack/usb_core/device/sources/controller/khci/: khci_dev.c khci_dev.h khci_dev_misc.h
  group src/usb_stack/usb_core/hal
    ../../../../src/usb_stack/usb_core/hal/: fsl_usb_ehci_hal.h fsl_usb_khci_hal.c fsl_usb_khci_hal.h
  group src/usb_stack/usb_core/include
    ../../../../src/usb_stack/usb_core/include/: compiler.h types.h usb.h usb_desc.h usb_ehci.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: sram_init_cm0plus.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group kl25z4
    ../../src/: bootloader_config.h clock_config_MKL25Z4.c hardware_init_MKL25Z4.c memory_map_MKL25Z4.c peripherals_MKL25Z4.c
    ../../../common/src/: bl_i2c_irq_config_common.c
