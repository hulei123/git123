# IAR project flashloader_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NDEBUG; CPU_MKV31F512VLL12; IAR; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../flashloader/output; ../../src; ../../../../src/include; ../../../../src/include/device; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG; LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKV31F51212/KV31F512xxx12_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; IAR; BL_TARGET_FLASH
  AARM.ADefines: LITE_FOOTPRINT
  group link
    ../../../common/linker/iar/MKV31F51212/: KV31F512xxx12_flashloader_loader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../../../src/startup/MKV31F51212/iar/: startup_MKV31F51212.s
    ../../../../src/startup/MKV31F51212/: system_MKV31F51212.c
  group src/bootloader
    ../../../../src/bootloader/: flashloader_image.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_flashloader.c
  group src/include
    ../../../../src/include/: bootloader_common.h fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group MKV31F51212
    ../../src/: bootloader_config.h
